# Autodesk Inventor part: Board
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-03
Part Number: Board
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: Board
Author: Administrator
## Design history (mm, degrees)
feature "Board"
body "Solid1"
