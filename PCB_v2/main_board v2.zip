# Autodesk Inventor part: 1X06
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-04
Part Number: 1X06
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: 1X06
Author: Administrator
## Design history (mm, degrees)
feature "Body2"
body "Solid1"
