# Autodesk Inventor part: R0805
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2020-04
Part Number: R0805
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: R0805
Author: Administrator
## Design history (mm, degrees)
feature "Body2"
body "Solid1"
